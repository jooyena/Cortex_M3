# Keil uVision project MatchingGame.uvproj, settings and files
target Simulator (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group Source
    ./: MatchingGame.c
  group Documentation
    ./: Abstract.txt
  group Drive
    ./: GLCD.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_clkpwr.c LPC1768_utility.c LPC1768_fnd.c lpc17xx_timer.c lpc17xx_gpio.c lpc17xx_exti.c
target MCB1700 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MatchingGame
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\ARM\INC\NXP\LPC17xx;C:\Huins_NXP_LPC1768_Library\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
